# Keil uVision project HelloIKS01A3.uvprojx, settings and files
target ITSboard (6190000::V6.19::ARMCLANG)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ITSboard +hex
  c flags: Optim=7 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: STM32F429xx,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO_144
  c include: ./Inc;../../stm32cubef4/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../stm32cubef4/Drivers/CMSIS/Include;../../stm32cubef4/Drivers/STM32F4xx_HAL_Driver/Inc;../../stm32cubef4/Drivers/BSP/STM32F4xx_Nucleo_144;../../stm32cubef4/Utilities/Fonts;../../DisplayWaveshare/Inc;../../ITS_BRD_LIB/Inc;../../ITS_BRD_LIB/Utilities/AddFonts;../../ITS_BRD_Sensorik/MEMS/App;../../ITS_BRD_Sensorik/Core/Inc;../../ITS_BRD_Sensorik/Drivers/BSP/IKS01A3;../../ITS_BRD_Sensorik/Drivers/BSP/STM32F4xx_Nucleo;../../ITS_BRD_Sensorik/MEMS/Target;../../ITS_BRD_Sensorik/Drivers/BSP/Components/Common;../../ITS_BRD_Sensorik/Drivers/BSP/Components/hts221;../../ITS_BRD_Sensorik/Drivers/BSP/Components/lis2dw12;../../ITS_BRD_Sensorik/Drivers/BSP/Components/lis2mdl;../../ITS_BRD_Sensorik/Drivers/BSP/Components/lps22hh;../../ITS_BRD_Sensorik/Drivers/BSP/Components/lsm6dso;../../ITS_BRD_Sensorik/Drivers/BSP/Components/stts751;../../ITS_BRD_Sensorik/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Doc
    ./: README.md
  group Drivers/BSP/STM32F4xx_Nucleo_144
    ../../stm32cubef4/Drivers/BSP/STM32F4xx_Nucleo_144/: stm32f4xx_nucleo_144.c
  group Drivers/Board
    ../../ITS_BRD_LIB/Src/startup/: system_stm32f4xx.c stm32f4xx_it.c startup_stm32f429xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../stm32cubef4/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_eth.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c
  group Program/User
    ./Src/: main.c
  group Utils
    ../../stm32cubef4/Utilities/Fonts/: font8.c font12.c font16.c font20.c font24.c
    ../../ITS_BRD_LIB/Utilities/AddFonts/: Consolas40.c Consolas60.c Consolas80.c Consolas90.c ConsolasBold40.c ConsolasBold60.c ConsolasBold80.c ConsolasBold90.c CourierNew48.c CourierNewBold40.c CourierNewBold60.c FiraMono40.c FiraMono60.c FiraMono80.c FiraMono90.c FiraMonoMedium40.c FiraMonoMedium60.c FiraMonoMedium80.c FiraMonoMedium90.c fontsFLASH.c
  group LCD
    ../../DisplayWaveshare/Src/: LCD_Driver.c LCD_GUI.c LCD_Touch.c LCD_SPI.c LCD_GPIO.c LCD_TIM.c LCD_Tools.c testsoftware.c LCD_Debug.c LCD_Demos.c
  group ITS_BRD_LIB
    ../../ITS_BRD_LIB/Src/: delay.c error.c init.c keypad.c lcd.c retarget_io.c stdinout_USART.c terminal.c timer.c USART_STM32F4xx.c
  group Program/Header
    ../../ITS_BRD_LIB/Inc/: lcd.h
  group Program/UserAssembler
    ./: main.s
  group ITS_BRD_Sensorik
    ../../ITS_BRD_Sensorik/Src/: iks01a3.c adc.c
  group ITS_BRD_Sensorik/Core
    ../../ITS_BRD_Sensorik/Core/Src/: stm32f4xx_nucleo_bus.c
  group ITS_BRD_Sensorik/Driver/BSP/Components
    ../../ITS_BRD_Sensorik/Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../ITS_BRD_Sensorik/Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../ITS_BRD_Sensorik/Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../ITS_BRD_Sensorik/Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../ITS_BRD_Sensorik/Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../ITS_BRD_Sensorik/Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
target ITSboard Assembler (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: as above
  output: ITSboard
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F429xx,USE_HAL_DRIVER,USE_STM32F4XX_NUCLEO_144
  c misc: --C99
  c include: ./Inc;../../stm32cubef4/Drivers/CMSIS/Device/ST/STM32F4xx/Include;../../stm32cubef4/Drivers/CMSIS/Include;../../stm32cubef4/Drivers/STM32F4xx_HAL_Driver/Inc;../../stm32cubef4/Drivers/BSP/STM32F4xx_Nucleo_144;../../stm32cubef4/Utilities/Fonts;../../DisplayWaveshare/Inc;../../ITS_BRD_LIB/Inc;../../ITS_BRD_LIB/Utilities/AddFonts
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.5.0
